FILESEXTRAPATHS_prepend_kernel-lab3-qemux86 := "${THISDIR}/${PN}:"
